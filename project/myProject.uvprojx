# Keil uVision project myProject.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myProject
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\lib\CMSIS\Device\ST\STM32F4xx\Include;..\lib\CMSIS\Include;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\drives\led;..\drives\fan;..\drives\key;..\drives\beep;..\drives\usart;..\drives\time;..\drives\i2c;..\drives\MAX30102;..\drives\SHT20;..\drives\M74HC595;..\drives\spi;..\drives\dma;..\drives\adc;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM4F;..\drives\systick;..\drives\wifi;..\drives\ASRPRO;..\drives\SG90;..\drives\algorithm;..\drives\myFreeRTOS;..\drives\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group apps
    ../apps/: main.c stm32f4xx_it.c
  group device
    ../drives/led/: led.c
    ../drives/fan/: fan.c
    ../drives/beep/: beep.c
    ../drives/key/: key.c
    ../drives/usart/: usart.c
    ../drives/time/: tim.c
    ../drives/i2c/: i2c.c
    ../drives/MAX30102/: MAX30102.c
    ../drives/SHT20/: SHT20.c
    ../drives/M74HC595/: M74HC595.c
    ../drives/spi/: spi.c
    ../drives/dma/: dma.c
    ../drives/adc/: adc.c
    ../drives/systick/: systick.c
    ../drives/wifi/: wifi.c
    ../drives/ASRPRO/: ASRPRO.c
    ../drives/SG90/: SG90.c
    ../drives/algorithm/: algorithm.c
    ../drives/myFreeRTOS/: myFreeRTOS.c
    ../drives/LCD/: LCD.c
  group lib
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cmsis
    ../lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group startup
    ../lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group freeRTOS
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
